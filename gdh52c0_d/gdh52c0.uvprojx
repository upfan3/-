# Keil uVision project gdh52c0.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: GD32F105VG GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gdh52c0 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL,USE_12MHZ
  c include: .\lib\Include;.\CMSIS\GD\GD32F10x\Include;.\CMSIS;.\user;.\FreeRTOS;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\net;.\canrule;.\usartrule
  memory RVCT4: ROM 0x8002000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ./user/: main.cpp i2c.cpp CAN.cpp USART.cpp oled_display.cpp adc.cpp E2PROM.cpp monitor.cpp InitData.cpp gpio.cpp database.cpp rtc.c h52c0.cpp Screen.cpp menuItem.cpp module.cpp SetMenuitem.cpp AlarmAndRecord.cpp battery.cpp DownElectronicCtrl.cpp Staggeredpeak.cpp moduleTP.cpp rtime.cpp user.cpp JinGui.cpp brainbattery.cpp
  group lib
    ./lib/Source/: gd32f10x_rcu.c gd32f10x_gpio.c gd32f10x_can.c gd32f10x_dbg.c gd32f10x_misc.c gd32f10x_usart.c gd32f10x_spi.c gd32f10x_adc.c gd32f10x_dma.c gd32f10x_rtc.c gd32f10x_bkp.c gd32f10x_pmu.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_timer.c
  group CMSIS
    ./CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ./CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
  group freeRTOS
    ./FreeRTOS/Source/: list.c tasks.c queue.c timers.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
  group CanRule
    ./canrule/: powercan.cpp canruleln.cpp
  group Task
    ./task/: UsartTask.cpp ScreenTask.cpp CanTask.cpp PortTask.cpp Swtmr1Callback.cpp Swtmr2Callback.cpp MonitorTask.cpp
  group UsartRule
    ./usartrule/: cydt1363.cpp
